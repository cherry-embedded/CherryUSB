# Keil uVision project USB_VCOM.uvprojx, settings and files
target MM32L373 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32L373PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\bsp\usblib;..\bsp;..\SYSTEM\delay;..\SYSTEM\uart;..\SYSTEM\sys;..\bsp\test;..\HARDWARE\UART;..\bsp\usblib;..\..\..\class\cdc;..\..\..\common;..\..\..\core;..\Device\MM32L3xx\HAL_lib\inc;..\Device\CMSIS\KEIL_CORE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Device/MM32L3xx/Source/: system_MM32L3xx.c
    ../Device/MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
  group HALlib
    ../Device/MM32L3xx/HAL_lib/src/: HAL_rcc.c
  group USER
    ../bsp/: main.c
    ../../: cdc_acm_template.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group usb_stack
    ../../../class/cdc/: usbd_cdc.c
    ../../../core/: usbd_core.c
    ../../../port/mm32/: usb_dc_mm32.c
software components: CMSIS:CORE 5.4.0
