# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC442JG8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.14
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Device\Nuvoton\NUC472_442\Include;..\StdDriver\inc;..\User;..\..\..\..\..\common;..\..\..\..\..\core;..\..\..\..\..\class\cdc;..\..\..\..\..\class\hid;..\..\..\..\..\class\msc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group Library
    ../StdDriver/src/: clk.c uart.c sys.c retarget.c
  group User
    ../User/: main.c
    ../../../../: cdc_acm_template.c
  group CherryUSB
    ../../../../../core/: usbd_core.c
    ../../../../../class/cdc/: usbd_cdc.c
    ../../../../../port/nuvoton/: usb_dc_nuvoton.c
