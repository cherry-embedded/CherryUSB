# Keil uVision project stm32h743xih6.uvprojx, settings and files
target stm32h743xih6 (6140001::V6.14.1::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h743xih6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,STM32H7,CONFIG_USBHOST_HIGH_WORKQ
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\..\..\..\..\core;..\..\..\..\..\common;..\..\..\..\..\osal;..\..\..\..\..\class\cdc;..\..\..\..\..\class\hid;..\..\..\..\..\class\msc;..\..\..\..\..\class\hub;..\..\..\..\..\third_party\FreeRTOS-10.4\include;..\..\..\..\..\third_party\FreeRTOS-10.4\portable\GCC\ARM_CM7\r0p1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../../../../: usb_host.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group FreeRTOS
    ../../../../../third_party/FreeRTOS-10.4/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/FreeRTOS-10.4/portable/MemMang/: heap_4.c
    ../../../../../third_party/FreeRTOS-10.4/portable/GCC/ARM_CM7/r0p1/: port.c
  group CherryUSB
    ../../../../../core/: usbh_core.c
    ../../../../../osal/: usb_osal_freertos.c usb_workq.c
    ../../../../../class/cdc/: usbh_cdc_acm.c
    ../../../../../class/hid/: usbh_hid.c
    ../../../../../class/msc/: usbh_msc.c
    ../../../../../port/dwc2/: usb_hc_dwc2.c
software components: CMSIS:CORE 5.4.0
