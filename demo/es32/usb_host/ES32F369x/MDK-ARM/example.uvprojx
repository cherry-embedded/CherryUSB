# Keil uVision project example.uvprojx, settings and files
target target (6140001::V6.14.1::ARMCLANG)
  device: ES32F3696LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.10
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: out +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_ASSERT,ES32F36xx,
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\EastSoft\ES32F36xx\Include;..\..\..\Drivers\ALD\ES32F36xx\Include;..\Inc;..\..\..\..\..\common;..\..\..\..\..\core;..\..\..\..\..\class\cdc;..\..\..\..\..\class\hid;..\..\..\..\..\class\msc;..\..\..\..\..\class\hub;..\..\..\..\..\class\wireless;..\..\..\..\..\osal;..\..\..\..\..\third_party\FreeRTOS-10.4\include;..\..\..\..\..\third_party\FreeRTOS-10.4\portable\GCC\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group startup
    ../../../Drivers/CMSIS/Device/EastSoft/ES32F36xx/Startup/keil/: startup_es32f36xx.s
  group ald
    ../../../Drivers/ALD/ES32F36xx/Source/: ald_bkpc.c ald_cmu.c ald_dma.c ald_gpio.c ald_iap.c ald_pmu.c ald_rmu.c ald_uart.c ald_usb.c utils.c
  group app
    ../Src/: main.c irq.c
    ../../../../: usb_host.c
  group CherryUSB
    ../../../../../core/: usbh_core.c
    ../../../../../class/cdc/: usbh_cdc_acm.c
    ../../../../../class/msc/: usbh_msc.c
    ../../../../../class/hid/: usbh_hid.c
    ../../../../../class/hub/: usbh_hub.c
    ../../../../../class/wireless/: usbh_rndis.c
    ../../../../../osal/: usb_osal_freertos.c usb_workq.c
    ../../../../../port/musb/: usb_hc_musb.c
  group FreeRTOS
    ../../../../../third_party/FreeRTOS-10.4/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/FreeRTOS-10.4/portable/MemMang/: heap_4.c
    ../../../../../third_party/FreeRTOS-10.4/portable/GCC/ARM_CM3/: port.c
